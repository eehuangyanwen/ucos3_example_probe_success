# Keil uVision project uCOS-III.uvproj, settings and files
target uCOS-III (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uCOS-III +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\uCOS-III;..\..\uCOS-III\KeilMDK;..\..\BSP;..\..\BSP\KeilMDK;..\..\BSP\OS\uCOS-III;..\..\BSP\ST\STM32L1xx\inc;..\..\..\..\..\uC-CPU;..\..\..\..\..\uC-CPU\ARM-Cortex-M3\RealView;..\..\..\..\..\uC-LIB;..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\..\..\..\..\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\..\..\..\..\uCOS-III\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group APP
    ../: app.c app_cfg.h cpu_cfg.h includes.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h stm32l1xx.h stm32l1xx_conf.h
  group BSP
    ../../BSP/: bsp.c bsp.h bsp_int.c bsp_periph.c
    ../../BSP/KeilMDK/: cstartup.s
    ../../BSP/OS/uCOS-III/: bsp_os.c bsp_os.h
  group uC/CPU
    ../../../../../uC-CPU/ARM-Cortex-M3/RealView/: cpu_c.c cpu.h cpu_a.asm
    ../../../../../uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    ../../../../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-III Port
    ../../../../../uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group uC/OS-III Source
    ../../../../../uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os.h os_type.h
  group STM32L1xx Library
    ../../BSP/ST/STM32L1xx/inc/: misc.h stm32l1xx_adc.h stm32l1xx_aes.h stm32l1xx_comp.h stm32l1xx_crc.h stm32l1xx_dac.h stm32l1xx_dbgmcu.h stm32l1xx_dma.h stm32l1xx_exti.h stm32l1xx_flash.h stm32l1xx_fsmc.h stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_iwdg.h stm32l1xx_lcd.h stm32l1xx_opamp.h stm32l1xx_pwr.h stm32l1xx_rcc.h stm32l1xx_rtc.h stm32l1xx_sdio.h stm32l1xx_spi.h stm32l1xx_syscfg.h stm32l1xx_tim.h stm32l1xx_usart.h stm32l1xx_wwdg.h
    ../../BSP/ST/STM32L1xx/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
